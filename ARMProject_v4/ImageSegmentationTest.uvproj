# Keil uVision project ImageSegmentationTest.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: ImageSegmentationTest
  c flags: Optim=1
  memory RVCT1: ROM 0x0 size 0x40000000
  memory RVCT9: RAM 0x40000000 size 0x20000000
  group Source Group 1
    ./: S3C2410A.s LabelOptimization.c ImageSegmentation.c
