# Keil uVision project uart_test.uvproj, settings and files
target Uart_test (ARM-ADS)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: uart_test
  c flags: Optim=1
  c include: ..\common\inc
  memory RVCT1: ROM 0x30000000 size 0x100000
  memory RVCT6: RAM 0x30200000 size 0x1e00000
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: ..\common\RuninRAM.sct
  group StartUp
    ../common/src/: S3C2410A.s
  group Source
    ./: main.c
    ./src/: camera_control.c imageOriginal_B.c imageOriginal_G.c imageOriginal_R.c
    ./src/decoder/: jidctflt.c loadjpeg.c tinyjpeg.c
  group Common
    ../common/src/: 2410lib.c sys_init.c
  group Script
    ../common/: RuninFlash.sct RuninRAM.sct DebugInRam.ini
  group ReadMe
    ./: readme.txt
